options:
  parameters:
    author: Lime Microsystems
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: GFSK loopback
  states: {}

blocks:
- name: baseband
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,2
    label: TX Baseband [MHz]
    type: real
    value: '446.094'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Gain [dB]
    min_len: '70'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: pa_path
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1,1,1
    label: PA Path
    label0: Auto
    label1: Band1
    label2: Band2
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: limesdr_sink_0_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: gain
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: baseband*1e6
    samp_rate: samp_rate
    serial: 00090706024D1312
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 5e6
    analog_bandw_ch1: 10e6
    calibr_bandw_ch1: '0'
    ch_align: 'False'
    channel_mode: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: gain
    gain_dB_ch1: '40'
    lna_path_ch0: '2'
    lna_path_ch1: '1'
    oversample: '0'
    rf_freq: baseband*1e6
    samp_rate: samp_rate
    serial: 00090706024D1312
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: baseband*1e6
    fftsize: '2048'
    gui_hint: 3,0,1,1
    name: '"Transmiting data"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: baseband*1e6
    fftsize: '2048'
    gui_hint: 3,1,1,1
    name: '"Receive data"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    entags: 'False'
    gui_hint: 2,1,1,1
    label1: ''
    label2: ''
    name: Received Signal
    size: 1024*200
    srate: 2.4e6
    style1: '0'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    entags: 'False'
    gui_hint: 2,0,1,1
    label1: ''
    label2: ''
    name: Transmmit Signal
    size: 1024*200
    srate: 2.4e6
    style1: '0'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', limesdr_sink_0_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [limesdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [limesdr_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
